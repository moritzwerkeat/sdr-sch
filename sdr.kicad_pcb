# Repository moritzwerkeat/sdr-sch (continued)

## KiCad design sdr.kicad_pcb (continued)

Board: 2 copper layers, 298 parts (0 on the bottom side), 240 nets, no tracks yet.

Other parts of the board:
C37: 100nF; C_0603_1608Metric
IC13: 74LVC30ADJ; SOIC127P600X175-14N
IC18, IC19, IC20, IC21, IC22, IC23, IC24, IC25, IC26, IC27: L8050QLT1G
LED6, LED7, LED8, LED9, LED10: LTRBR37G-4R4S-0125-0-2-R18; LTRBR37G4R4S012502R18
R23, R24, R27, R30, R56, R58, R60, R61, R62, R65, R66, R67, R70, R71, R72: 4.7K; R_0603_1608Metric
R28, R29, R57, R59, R63, R64, R68, R69, R73, R74: 47R; R_0603_1608Metric

Their connections:
+3.3V: C37.1, IC13.6 (F), IC13.11 (G), IC13.12 (H), IC13.14 (VCC); also elsewhere on the board
+3V3: LED6.1 (ANODE), LED7.1 (ANODE), LED8.1 (ANODE), LED9.1 (ANODE), LED10.1 (ANODE), R28.2, R59.2, R63.2, R68.2, R73.2; also elsewhere on the board
/LED2/P10: IC13.1 (A), IC18.3 (C), R59.1
/LED2/P11: IC13.2 (B), IC20.3 (C), R28.1
/LED2/P12: IC13.3 (C), IC22.3 (C), R63.1
/LED2/P13: IC13.4 (D), IC24.3 (C), R68.1
/LED2/P14: IC13.5 (E), IC26.3 (C), R73.1
GND: C37.2, IC13.7 (GND), R23.1, R27.1, R30.1, R58.1, R60.1, R62.1, R65.1, R67.1, R70.1, R72.1; also elsewhere on the board
K10: R56.1; also elsewhere on the board
K11: R24.1; also elsewhere on the board
K12: R61.1; also elsewhere on the board
K13: R66.1; also elsewhere on the board
K14: R71.1; also elsewhere on the board
unnamed: IC18.1 (B), IC19.1 (B), R56.2
unnamed: IC18.2 (E), R60.2
unnamed: IC19.3 (C), R57.1
unnamed: IC19.2 (E), R58.2
unnamed: IC20.1 (B), IC21.1 (B), R24.2
unnamed: IC20.2 (E), R23.2
unnamed: IC21.3 (C), R29.1
unnamed: IC21.2 (E), R27.2
unnamed: IC22.1 (B), IC23.1 (B), R61.2
unnamed: IC22.2 (E), R30.2
unnamed: IC23.3 (C), R64.1
unnamed: IC23.2 (E), R62.2
unnamed: IC24.1 (B), IC25.1 (B), R66.2
unnamed: IC24.2 (E), R65.2
unnamed: IC25.3 (C), R69.1
unnamed: IC25.2 (E), R67.2
unnamed: IC26.1 (B), IC27.1 (B), R71.2
unnamed: IC26.2 (E), R70.2
unnamed: IC27.3 (C), R74.1
unnamed: IC27.2 (E), R72.2
unnamed: LED6.2 (R), LED6.3 (B), LED6.4 (G), R57.2
unnamed: LED7.2 (R), LED7.3 (B), LED7.4 (G), R29.2
unnamed: LED8.2 (R), LED8.3 (B), LED8.4 (G), R64.2
unnamed: LED9.2 (R), LED9.3 (B), LED9.4 (G), R69.2
unnamed: LED10.2 (R), LED10.3 (B), LED10.4 (G), R74.2
P1: IC13.8 (Y); also elsewhere on the board
